# Keil uVision project BatteryTestSTM32F103.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BatteryTestSTM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\USER\MID;..\USER\HAL;..\USER\APP;..\Libraries\inc;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: Delay.c main.c PUB_LIB.c stm32f10x_it.c system_stm32f10x.c Global.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s
  group HAL
    ../USER/HAL/: hal_electric.c hal_keyboard.c hal_led.c hal_nvmem.c hal_switch.c hal_timer.c hal_uart.c
  group MID
    ../USER/MID/: mid_electric.c mid_keyboard.c mid_nvmem.c
  group APP
    ../USER/APP/: app_task.c
  group FWLIB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
